# Keil uVision project Homework5.1.uvproj, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: Homework5.1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  group Source Group 1
    Z:/ELEN_120L/: startup_cm4.s
    ./: main.s
